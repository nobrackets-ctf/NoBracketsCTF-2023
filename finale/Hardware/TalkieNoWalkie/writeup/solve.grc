options:
  parameters:
    generate_options: qt_gui
    id: solve
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '176400'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate/4
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/daeras/ctf/challmaking/nobracket2023/NoBrackets-CTF-2023-Challenges-Finale/Hardware/TalkieNoWalkie/ressources/interception.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/daeras/RES
    format: FORMAT_WAV
    samp_rate: '44100'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_file_source_1, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
